#include "app_blufi.h"
#include "app_wifi.h"
#include "app_speaker.h"
#include "app_cmd.h"
#include "app_config.h"

#include "esp_bt.h"
#include "esp_bt_device.h"
#include "esp_bt_main.h"
#include "esp_gap_ble_api.h"
#include "esp_blufi_api.h"
#include "esp_blufi.h"
#include "esp_wifi.h"
#include "esp_mac.h"

#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include "esp_system.h"

#include <string.h>
#include <stdio.h>

static const char *TAG = "app_blufi";

/* ================== TRẠNG THÁI ================== */
static bool              g_bInited       = false;                   // biến kiểm tra Module đã Init
static bool              g_bRunning      = false;                   // blufi đang chạy
static bool              g_bBleConnected = false;                   // app đã gửi connect BLE
static bool              g_bRequestEnd   = false;                   // Stop() / xong config → thoát timeout task
static bool              g_bWifiOk       = false;                   //Đã Got IP trong session
static app_blufi_state_t g_eState        = APP_BLUFI_STATE_IDLE;    // 

static wifi_config_t     g_stStaConfig   = {0};                     // SSID/pass nhận từ App hay chưa 
static TaskHandle_t      g_hTimeoutTask  = NULL;                    // Handle task timeout

/* ================== ADV ================== */
static uint8_t g_au8ServiceUuid128[16] = {
    0xfb, 0x34, 0x9b, 0x5f, 0x80, 0x00, 0x00, 0x80,
    0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
};

static esp_ble_adv_data_t g_stAdvData = {
    .set_scan_rsp        = false,
    .include_name        = true,
    .include_txpower     = true,
    .min_interval        = 0x0006,
    .max_interval        = 0x0010,
    .appearance          = 0x00,
    .manufacturer_len    = 0,
    .p_manufacturer_data = NULL,
    .service_data_len    = 0,
    .p_service_data      = NULL,
    .service_uuid_len    = 16,
    .p_service_uuid      = g_au8ServiceUuid128,
    .flag                = (ESP_BLE_ADV_FLAG_GEN_DISC | ESP_BLE_ADV_FLAG_BREDR_NOT_SPT),
};

static esp_ble_adv_params_t g_stAdvParams = {
    .adv_int_min       = 0x100,
    .adv_int_max       = 0x100,
    .adv_type          = ADV_TYPE_IND,
    .own_addr_type     = BLE_ADDR_TYPE_PUBLIC,
    .channel_map       = ADV_CHNL_ALL,
    .adv_filter_policy = ADV_FILTER_ALLOW_SCAN_ANY_CON_ANY,
};

/* ================== FORWARD ================== */
static void app_blufi_EventCallback(esp_blufi_cb_event_t event, esp_blufi_cb_param_t *param);
static void app_blufi_NegotiateDataHandler(uint8_t *data, int len, uint8_t **output_data, int *output_len, bool *need_free);

static esp_blufi_callbacks_t g_stBlufiCallbacks = {
    .event_cb               = app_blufi_EventCallback,
    .negotiate_data_handler = app_blufi_NegotiateDataHandler,
    .encrypt_func           = NULL,
    .decrypt_func           = NULL,
    .checksum_func          = NULL,
};

/* ================== HELPER ================== */

static void app_blufi_SetState(app_blufi_state_t e)
{
    g_eState = e;
    LREP(TAG, "state → %d", (int)e);
}

static void app_blufi_SendWifiReport(bool bSuccess)
{
    if (!g_bBleConnected) return;

    wifi_mode_t mode = WIFI_MODE_STA;
    esp_wifi_get_mode(&mode);

    esp_err_t ret = esp_blufi_send_wifi_conn_report(
        mode,
        bSuccess ? ESP_BLUFI_STA_CONN_SUCCESS : ESP_BLUFI_STA_CONN_FAIL,
        0, NULL);

    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "send_wifi_conn_report: %s", esp_err_to_name(ret));
    } else {
        LREP(TAG, "Wi-Fi report: %s", bSuccess ? "SUCCESS" : "FAIL");
    }
}

/* Xử lý Custom Data nội bộ */
static void app_blufi_HandleCustomData(const uint8_t *data, int len)
{
    char buf[DF_BLUFI_CUSTOM_MSG_MAX];
    int n = (len < (int)sizeof(buf) - 1) ? len : (int)sizeof(buf) - 1;
    memcpy(buf, data, n);
    buf[n] = '';
    LREP(TAG, "Custom Data: %s", buf);

    /* Parse JSON command (CmdGetDeviceID / CmdSetDeviceConfig / ...) */
    app_cmd_Handle(buf, APP_CMD_SRC_BLUFI);
}

/* Beep kết quả khi session kết thúc */
static void app_blufi_NotifyResult(bool bSuccess)
{
    if (bSuccess) {
        LREP(TAG, "BluFi SUCCESS");
        app_speaker_PlayByID(SPEAKER_SOUND_STARTUP_SUCCESS);
    } else {
        LREP_WARNING(TAG, "BluFi FAIL / TIMEOUT");
        app_speaker_PlayBeep(400, 300, 80);
    }
}

/* ================== GỌI TỪ app_wifi ================== */

void app_blufi_OnWifiResult(bool bGotIp)
{
    if (!g_bRunning) return;

    if (bGotIp) {
        LREP(TAG, "Wi-Fi Got IP trong BluFi session");
        g_bWifiOk = true;
        app_blufi_SetState(APP_BLUFI_STATE_SUCCESS);
        app_blufi_SendWifiReport(true);
        /* Giong firmware goc: sau SUCCESS gui CmdGetDeviceID cho App */
        app_cmd_SendGetDeviceIdResponse(APP_CMD_SRC_BLUFI);
        /* Co the ket thuc session: Wi-Fi OK la du cho them thiet bi.
         * Neu App con gui Custom Data, van nhan duoc truoc khi timeout task dong. */
    } else {
        /* Chi bao FAIL neu chua tung Got IP; tranh spam khi App goi reconnect */
        if (!g_bWifiOk) {
            LREP_WARNING(TAG, "Wi-Fi disconnect trong BluFi session");
            app_blufi_SendWifiReport(false);
        } else {
            LREP_WARNING(TAG, "Wi-Fi disconnect sau khi da OK (bo qua report FAIL)");
        }
        g_bWifiOk = false;
    }
}

/* ================== BLUFI EVENT ================== */

static void app_blufi_EventCallback(esp_blufi_cb_event_t event, esp_blufi_cb_param_t *param)
{
    switch (event) {
        case ESP_BLUFI_EVENT_INIT_FINISH: {
            LREP(TAG, "BLUFI init finish");
            uint8_t mac[6] = {0};
            app_wifi_GetMac(mac);
            char name[24];
            snprintf(name, sizeof(name), "%s%02X%02X", DF_BLUFI_ADV_NAME_PREFIX, mac[4], mac[5]);
            LREP(TAG, "Adv name: %s", name);
            esp_ble_gap_set_device_name(name);
            esp_ble_gap_config_adv_data(&g_stAdvData);
            app_blufi_SetState(APP_BLUFI_STATE_ADVERTISING);
            break;
        }

        case ESP_BLUFI_EVENT_DEINIT_FINISH:{
            LREP(TAG, "BLUFI deinit finish");
            break;
        }

        case ESP_BLUFI_EVENT_BLE_CONNECT:{
            LREP(TAG, "BLE connected");
            g_bBleConnected = true;
            esp_ble_gap_stop_advertising();
            app_blufi_SetState(APP_BLUFI_STATE_CONNECTED);
            break;
        }

        case ESP_BLUFI_EVENT_BLE_DISCONNECT:{
            LREP(TAG, "BLE disconnected");
            g_bBleConnected = false;
            if (g_bRunning && !g_bRequestEnd) {
                esp_ble_gap_start_advertising(&g_stAdvParams);
                app_blufi_SetState(APP_BLUFI_STATE_ADVERTISING);
            }
            break;
        }
        
        case ESP_BLUFI_EVENT_SET_WIFI_OPMODE:{
            LREP(TAG, "Set WIFI opmode %d", param->wifi_mode.op_mode);
            if (param->wifi_mode.op_mode == WIFI_MODE_STA) {
                esp_wifi_set_mode(WIFI_MODE_STA);
            } else {
                LREP_WARNING(TAG, "Chi ho tro STA mode");
            }
            break;
        }

        case ESP_BLUFI_EVENT_REQ_CONNECT_TO_AP: {
            LREP(TAG, "Request connect to AP");
            const char *ssid = (const char *)g_stStaConfig.sta.ssid;
            const char *pass = (const char *)g_stStaConfig.sta.password;

            /* Neu da co IP roi → chi gui report SUCCESS, khong disconnect/reconnect */
            if (app_wifi_IsConnected()) {
                LREP(TAG, "Da ket noi Wi-Fi, gui lai SUCCESS report");
                g_bWifiOk = true;
                app_blufi_SetState(APP_BLUFI_STATE_SUCCESS);
                app_blufi_SendWifiReport(true);
                break;
            }

            if (ssid[0] == '\0') {
                LREP_ERROR(TAG, "SSID chua nhan duoc");
                app_blufi_SendWifiReport(false);
                break;
            }

            app_blufi_SetState(APP_BLUFI_STATE_CONFIGURING);
            app_wifi_Disconnect();
            app_common_DelayMs(100);
            app_wifi_ConnectWithConfig(ssid, pass);
            break;
        }

        case ESP_BLUFI_EVENT_REQ_DISCONNECT_FROM_AP:{
            LREP(TAG, "Request disconnect from AP");
            app_wifi_Disconnect();
            break;
        }

        case ESP_BLUFI_EVENT_GET_WIFI_STATUS:{
            LREP(TAG, "Get Wi-Fi status");
            app_blufi_SendWifiReport(app_wifi_IsConnected());
            break;
        }

        case ESP_BLUFI_EVENT_RECV_STA_BSSID:{
            memcpy(g_stStaConfig.sta.bssid, param->sta_bssid.bssid, 6);
            g_stStaConfig.sta.bssid_set = 1;
            esp_wifi_set_config(WIFI_IF_STA, &g_stStaConfig);
            LREP(TAG, "Recv STA BSSID");
            break;
        }

        case ESP_BLUFI_EVENT_RECV_STA_SSID:{
            strncpy((char *)g_stStaConfig.sta.ssid,
                    (char *)param->sta_ssid.ssid,
                    param->sta_ssid.ssid_len);
            g_stStaConfig.sta.ssid[param->sta_ssid.ssid_len] = '\0';
            esp_wifi_set_config(WIFI_IF_STA, &g_stStaConfig);
            LREP(TAG, "Recv STA SSID: %s", g_stStaConfig.sta.ssid);
            break;
        }

        case ESP_BLUFI_EVENT_RECV_STA_PASSWD:{
            strncpy((char *)g_stStaConfig.sta.password,
                    (char *)param->sta_passwd.passwd,
                    param->sta_passwd.passwd_len);
            g_stStaConfig.sta.password[param->sta_passwd.passwd_len] = '\0';
            esp_wifi_set_config(WIFI_IF_STA, &g_stStaConfig);
            LREP(TAG, "Recv STA PASSWD (len=%d)", param->sta_passwd.passwd_len);
            break;
        }

        case ESP_BLUFI_EVENT_RECV_CUSTOM_DATA:{
            LREP(TAG, "Recv Custom Data len=%d", param->custom_data.data_len);
            if (param->custom_data.data && param->custom_data.data_len > 0) {
                app_blufi_HandleCustomData(param->custom_data.data, param->custom_data.data_len);
            }
            break;
        }

        case ESP_BLUFI_EVENT_REPORT_ERROR:{
            LREP_ERROR(TAG, "BluFi report error: %d", param->report_error.state);
            break;
        }

        case ESP_BLUFI_EVENT_RECV_SLAVE_DISCONNECT_BLE:{
            LREP(TAG, "App requested disconnect BLE ");
            esp_blufi_close(g_u8ServerIf, g_u16ConnId);
            if (app_wifi_IsConnected()) {
                g_bRequestEnd = true;
            }
            break;
        }

        default:
            LREP_DEBUG(TAG, "event %d", event);
            break;
    }
}

static void app_blufi_NegotiateDataHandler(uint8_t *data, int len,
                                           uint8_t **output_data, int *output_len,
                                           bool *need_free)
{
    (void)data;
    (void)len;
    *output_data = NULL;
    *output_len  = 0;
    *need_free   = false;
}

/* ================== TIMEOUT TASK ================== */

static void app_blufi_TimeoutTask(void *pvParam)
{
    (void)pvParam;
    int sec = 0;
    LREP(TAG, "Timeout task started (%d s)", DF_BLUFI_TIMEOUT_SEC);

    int wifi_ok_sec = -1;  /* moc thoi diem Got IP */
    while (g_bRunning && !g_bRequestEnd) {
        vTaskDelay(pdMS_TO_TICKS(1000));
        sec++;
        if (sec % 10 == 0) {
            LREP(TAG, "BluFi remain: %d s", DF_BLUFI_TIMEOUT_SEC - sec);
        }
        /* Danh dau thoi diem Wi-Fi OK */
        if (g_bWifiOk && wifi_ok_sec < 0) {
            wifi_ok_sec = sec;
            LREP(TAG, "Wi-Fi OK at t=%ds, cho Custom Data toi da 15s", sec);
        }
        /* Sau Got IP: cho them 15s roi ket thuc (thanh cong) */
        if (wifi_ok_sec >= 0 && (sec - wifi_ok_sec) >= 15) {
            LREP(TAG, "Het thoi gian cho Custom Data, ket thuc session");
            break;
        }
        if (sec >= DF_BLUFI_TIMEOUT_SEC) {
            LREP_WARNING(TAG, "BluFi timeout!");
            break;
        }
    }

    /* Thanh cong neu da Got IP (them thiet bi OK), Custom Data la tuy chon */
    bool bSuccess = g_bWifiOk || (g_bRequestEnd && app_wifi_IsConnected());
    LREP(TAG, "BluFi session end, success=%d (wifiOk=%d requestEnd=%d)",
         bSuccess, g_bWifiOk, g_bRequestEnd);

    esp_ble_gap_stop_advertising();
    if (g_bBleConnected) {
        esp_blufi_disconnect();  /* IDF 5.x: thay cho esp_blufi_close */
        app_common_DelayMs(200);
    }

    esp_blufi_profile_deinit();
    esp_bluedroid_disable();
    esp_bluedroid_deinit();
    esp_bt_controller_disable();
    esp_bt_controller_deinit();

    g_bRunning      = false;
    g_bBleConnected = false;
    app_blufi_SetState(bSuccess ? APP_BLUFI_STATE_SUCCESS : APP_BLUFI_STATE_FAIL);

    app_blufi_NotifyResult(bSuccess);
    if (bSuccess) {
        LREP(TAG, "BluFi SUCCESS → restart sau 1s");
        app_common_DelayMs(1000);
        esp_restart();
    }
    g_hTimeoutTask = NULL;
    vTaskDelete(NULL);
}

/* ================== API ================== */

int32_t app_blufi_Init(void)
{
    if (g_bInited) return ERROR_CODE_OK;
    g_bInited = true;
    g_eState  = APP_BLUFI_STATE_IDLE;
    LREP(TAG, "BluFi module ready");
    return ERROR_CODE_OK;
}

int32_t app_blufi_Start(void)
{
    if (g_bRunning) {
        LREP_WARNING(TAG, "BluFi dang chay");
        return ERROR_CODE_BLUFI_ALREADY_RUNNING;
    }

    LREP(TAG, "Bắt đầu khởi chạy Blufi.......");
    app_blufi_SetState(APP_BLUFI_STATE_STARTING);
    g_bRequestEnd   = false;
    g_bBleConnected = false;
    g_bWifiOk       = false;
    memset(&g_stStaConfig, 0, sizeof(g_stStaConfig));

    app_wifi_Disconnect();

    esp_err_t ret;
    esp_bt_controller_config_t bt_cfg = BT_CONTROLLER_INIT_CONFIG_DEFAULT();

    ret = esp_bt_controller_init(&bt_cfg);
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "bt_controller_init: %s", esp_err_to_name(ret));
        app_blufi_SetState(APP_BLUFI_STATE_FAIL);
        return ERROR_CODE_BLUFI_INIT_FAIL;
    }
    ret = esp_bt_controller_enable(ESP_BT_MODE_BLE);
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "bt_controller_enable: %s", esp_err_to_name(ret));
        esp_bt_controller_deinit();
        app_blufi_SetState(APP_BLUFI_STATE_FAIL);
        return ERROR_CODE_BLUFI_INIT_FAIL;
    }

    ret = esp_bluedroid_init();
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "bluedroid_init: %s", esp_err_to_name(ret));
        esp_bt_controller_disable();
        esp_bt_controller_deinit();
        app_blufi_SetState(APP_BLUFI_STATE_FAIL);
        return ERROR_CODE_BLUFI_INIT_FAIL;
    }
    ret = esp_bluedroid_enable();
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "bluedroid_enable: %s", esp_err_to_name(ret));
        esp_bluedroid_deinit();
        esp_bt_controller_disable();
        esp_bt_controller_deinit();
        app_blufi_SetState(APP_BLUFI_STATE_FAIL);
        return ERROR_CODE_BLUFI_INIT_FAIL;
    }

    ret = esp_blufi_register_callbacks(&g_stBlufiCallbacks);
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "blufi_register_callbacks: %s", esp_err_to_name(ret));
        goto fail_bt;
    }

    ret = esp_ble_gap_register_callback(esp_blufi_gap_event_handler);
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "gap_register_callback: %s", esp_err_to_name(ret));
        goto fail_bt;
    }

    ret = esp_blufi_profile_init();
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "blufi_profile_init: %s", esp_err_to_name(ret));
        goto fail_bt;
    }

    LREP(TAG, "BLUFI version 0x%04x", esp_blufi_get_version());
    esp_ble_gap_start_advertising(&g_stAdvParams);

    g_bRunning = true;

    if (xTaskCreate(app_blufi_TimeoutTask, "blufi_to",
                    DF_BLUFI_TASK_STACK, NULL,
                    DF_BLUFI_TASK_PRIO, &g_hTimeoutTask) != pdPASS) {
        LREP_ERROR(TAG, "Create timeout task failed");
    }

    LREP(TAG, "BluFi started, advertising...");
    return ERROR_CODE_OK;

fail_bt:
    esp_bluedroid_disable();
    esp_bluedroid_deinit();
    esp_bt_controller_disable();
    esp_bt_controller_deinit();
    app_blufi_SetState(APP_BLUFI_STATE_FAIL);
    return ERROR_CODE_BLUFI_INIT_FAIL;
}

void app_blufi_Stop(void)
{
    if (!g_bRunning) return;
    LREP(TAG, "BluFi STOP requested");
    g_bRequestEnd = true;
}

bool app_blufi_IsRunning(void)
{
    return g_bRunning;
}

app_blufi_state_t app_blufi_GetState(void)
{
    return g_eState;
}

int32_t app_blufi_SendCustomData(const uint8_t *data, int len)
{
    if (!g_bBleConnected || data == NULL || len <= 0) {
        return ERROR_CODE_FAIL;
    }
    esp_err_t ret = esp_blufi_send_custom_data((uint8_t *)data, len);
    if (ret != ESP_OK) {
        LREP_ERROR(TAG, "send_custom_data: %s", esp_err_to_name(ret));
        return ERROR_CODE_FAIL;
    }
    return ERROR_CODE_OK;
}
